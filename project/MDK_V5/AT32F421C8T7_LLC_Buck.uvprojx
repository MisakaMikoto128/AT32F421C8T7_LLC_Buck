# Keil uVision project AT32F421C8T7_LLC_Buck.uvprojx, settings and files
target AT32F421C8T7_LLC_Buck (6210000::V6.21::ARMCLANG)
  device: -AT32F421C8T7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.8
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32F421C8T7_LLC_Buck +hex
  AfterMake: ..\..\firmwaretools\keil-build-viewer.exe -NOOBJ AT32F421C8T7_LLC_Buck.uvprojx
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,AT_START_F421_V1,ULOG_ENABLED
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\BFL;..\..\3rdparty;..\..\3rdparty\SEGGER;..\..\3rdparty\ulog\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: at32f421_int.c at32f421_wk_config.c main.c wk_system.c wk_adc.c wk_tmr.c wk_dma.c wk_gpio.c wk_crc.c wk_pwc.c pid_q32.c
  group firmware
    ../../libraries/drivers/src/: at32f421_crm.c at32f421_tmr.c at32f421_gpio.c at32f421_pwc.c at32f421_adc.c at32f421_dma.c at32f421_debug.c at32f421_flash.c at32f421_crc.c at32f421_exint.c at32f421_misc.c at32f421_scfg.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f421.c
    ./: startup_at32f421.s
  group BFL
    ../../BFL/: log.c
  group 3rdparty
    ../../3rdparty/SEGGER/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../3rdparty/ulog/src/: ulog.c
